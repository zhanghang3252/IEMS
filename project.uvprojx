# Keil uVision project project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F407VG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F407,HXTAL_VALUE=8000000
  c include: .\lib\GD32F4xx_Firmware_Library\CMSIS;.\lib\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;.\lib\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;.\drive;.\user;.\lib\rtthread-nano\rt-thread\include;.\lib\rtthread-nano\rt-thread\config;.\lib\rtthread-nano\rt-thread\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group app
    ./user/: main.c main.h gd32f4xx_it.c gd32f4xx_it.h gd32f4xx_libopt.h systick.c systick.h
  group deiver
    ./drive/: led.c led.h usart.c usart.h rtc.c rtc.h sdcard.c sdcard.h rs485.c rs485.h can.c can.h I2C.c I2C.h at24cxx.c
  group Middleware
    ./Middleware/: linked_list.c linked_list.h
  group lib/GD32F4xx_Library
    ./lib/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group lib/GD32F4xx_Library/CMSIS
    ./lib/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ./lib/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
  group lib/rt_thead/src
    ./lib/rtthread-nano/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group lib/rt_thead/libcpu
    ./lib/rtthread-nano/rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group lib/rt_thead/finsh
    ./lib/rtthread-nano/rt-thread/components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group lib/rt_thead/config
    ./lib/rtthread-nano/rt-thread/config/: board.c rtconfig.h
  group rt_thread_function
    ./user/: rt_thread_function.h led_thread.c wifi_thread_function.c
